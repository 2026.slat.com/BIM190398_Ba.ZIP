Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-07-10T15:56:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 10 15:56:00 2019 * Host: DESKTOP-AJHKH4T * Database: C:\Users\xingo\AppData\Local\Temp\{0FFD2C58-EDBD-4C8B-B530-C3A0C8EF2EBA}\ifc * Database version: 5507 * Database creation date: Wed Jul 10 15:55:58 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 10 15:55:59 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 10 15:55:59 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT), BOX2:BOX2 - SDC-M 24V 3D BOX2 IP (SLAT):139298
In: Niveau 1
Type - Autre - Catégorie: Modèles génériques; datBIM.Classe electrique (Electrical class): 1; datBIM.Code datBIM entité: 81430213; datBIM.Code produit SLAT (Id SlatEntityCode): 81430213; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Consommation electrique (Primary current): 1,5; datBIM.Couleur dominante (Dominant color): Blanc (White); datBIM.Courant maximal d'utilisation (Maximal output current): 2,3; datBIM.Degre d'etancheite IP (Protection class IP): IP30; datBIM.Description longue entité: <p> <img title="SDC-M_BOX2.jpg" src="https://admin.datbim.com/media/mid/1/23076.jpg" alt="" width="250" height="187" data-idmedia="23076" /></p><p><em>Ref. : 81430213<br /></em></p><p>Le Micro-UPS DC SDC-M IP est communicant et dédié à la protection des équipements sensibles des bâtiments et des infrastructures. En cas de coupure de courant, il assure la continuité de service des équipements qu?il alimente grâce à la fonction secours LiFePO4 intégrée / The Micro-UPS DC SDC-M IP is communicating and dedicated to the protection of sensitive building and infrastructure equipment. In the event of a power failure, it ensures the continuity of service of the equipment it supplies thanks to the integrated LiFePO4 back-up function.</p>; datBIM.Designation technique (Technical designation): AES, EAE, EAES; datBIM.Duree de la garantie (Length of warranty): 3 ans; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Duree de vie previsionnelle de reconditionnement (Expected life of refurbishment): 10 ans; datBIM.Fonction generique (Generic function): Alimentation électrique secourue (Emergency power supply); datBIM.Hauteur (Height): 196 mm; datBIM.Hauteur hors tout (Height overall): 196 mm; datBIM.Id: datBIM:384057; datBIM.Largeur (Wide): 284 mm; datBIM.Largeur hors tout (Wide overall): 284 mm; datBIM.Libellé entité: SDC-M 24V 3D BOX2 IP; datBIM.Longueur (Length): 61.5 mm; datBIM.Longueur hors tout (Length overall): 63.5 mm; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): ABS - PC (ABS - Polycarbonate plastic); datBIM.Mode de communication (Communication mode): IP; datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 1; datBIM.Poids (Weight): 0.9; datBIM.Point de fixation (Mounting point): 4; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Puissance (Output power): 55 W; datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommande (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommande (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommande (Recommanded); datBIM.Rendement energetique (Energy efficiency): 90; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Temperature d'utilisation (Operating temperature): -5 à +55 °C; datBIM.Tension de fonctionnement [Min-Max] (Mains voltage [Min-Max]): 98-265 V; datBIM.Tension nominale de sortie (Rated output voltage): 24 V; datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): Mural (Wall-mounted); Nom de la famille: BOX2
Type - Données d'identification - Fabricant: SLAT; Nom du type: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT)
Pset_BuildingElementProxyCommon - Reference: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT)
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: BOX2: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT); Famille et type: BOX2: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT); ID du type: BOX2: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT); Type: BOX2: BOX2 - SDC-M 24V 3D BOX2 IP (SLAT)
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.0966792 m2; Volume: 0.00302067 m3
Phase de construction - Phase de création: Phase 1
